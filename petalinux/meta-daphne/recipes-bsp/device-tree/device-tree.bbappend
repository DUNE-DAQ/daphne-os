FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
  file://system-user.dtsi \
  file://daphne-k26c-network.dtsi \
"
